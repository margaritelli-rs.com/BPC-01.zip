Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: e20d6631-b70a-4bed-81cf-b4f37f53c667, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: BPC-01 3C.rfa.ifc
Time: 2025-10-19T12:30:17+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: BPC-01 3C_R23:BPC-01 3C_R23, BPC-01 3C_R23:BPC-01 3C_R23:14980
In: Livello 1
Type - Material: wood, <Unnamed>, Metal
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: BPC-01 3C_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; altezza: 1.1 mm; Costo: 147.5; Descrizione: (colore); EPD: no; GWP totale cradle to gate: n.a.; Installazione: Rilevato/Terreno; Interasse: 3; Legno CAM Strade: CoC PEFC; Lunghezza: n.a.; Materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: BPC-01 3C; Nome del tipo: BPC-01 3C_R23; Prezzo di Capitolato: 147.5; Prodotto: Protezione ciclabile a 3 correnti; Produttore: Margaritelli Road Safety; Unità di Misura: m; URL: https://margaritelli-rs.com/it/altri-prodotti/protezioni-ciclo-pedonali/; URL (certificati CE. DOP. manuali. schede tecniche. schemi): https://margaritelli-rs.com/it/altri-prodotti/protezioni-ciclo-pedonali/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: BPC-01 3C_R23
Pset_RailingCommon - Reference: BPC-01 3C_R23; IsExternal: no
Altro - Famiglia: BPC-01 3C_R23; Famiglia e tipo: BPC-01 3C_R23: BPC-01 3C_R23; ID tipo: 14964; Tipo: BPC-01 3C_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 9.40883 m2; Volume: 0.274052 m3
